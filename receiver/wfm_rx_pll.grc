<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wfm_rx_pll</value></param>
<param><key>title</key><value>Stereo FM Radio</value></param>
<param><key>author</key><value>OZ9AEC</value></param>
<param><key>description</key><value>WFM receiver (stereo)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>value</key><value>15</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,0,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>AF</value></param>
<param><key>value</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,2,1,2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_left</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>rr_stereo_left</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>rr_stereo_right</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_right</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_wfm_rcv_pll</key>
<param><key>id</key><value>wfm_rcv_pll</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>audio_decimation</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 250000, 20000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/usrp_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_decim</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>usrp_freq</value></param>
<param><key>label</key><value>USRP frequency</value></param>
<param><key>value</key><value>96.5e6</value></param>
<param><key>min</key><value>88e6</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,0,1,5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_tune</value></param>
<param><key>label</key><value>Fine frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-250e3</value></param>
<param><key>max</key><value>250e3</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,0,1,5</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>value</key><value>usrp_freq+xlate_tune</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>center_freq</key><value>-xlate_tune</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>B:</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>usrp_freq</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Uses daughterboard on side B</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fftsink_rf</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Baseband</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>1.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>1120,527</value></param>
<param><key>grid_pos</key><value>0,0,5,5</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>fftsink_rf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>wfm_rcv_pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wfm_rcv_pll</source_block_id><sink_block_id>rr_stereo_left</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wfm_rcv_pll</source_block_id><sink_block_id>rr_stereo_right</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rr_stereo_left</source_block_id><sink_block_id>af_gain_stereo_right</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rr_stereo_right</source_block_id><sink_block_id>af_gain_stereo_left</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_right</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
